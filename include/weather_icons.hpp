#pragma once
#ifndef WEATHER_ICONS_HPP
#define WEATHER_ICONS_HPP

#include <stdint.h>

// 16x8 weather icons, one byte per column (16 bytes per icon),
// bit 0 = top row (matches LMDS::setColumn / LEDMatrixDriver pixel order).
// Stored as plain arrays so host tests can render them without Arduino shims.

enum WeatherIcon
{
    WI_SUN = 0,
    WI_MOON,
    WI_PARTLY,
    WI_CLOUD,
    WI_DRIZZLE,
    WI_RAIN,
    WI_SNOW,
    WI_THUNDER,
    WI_FOG,
    WI_ARROW_UP_FAST,
    WI_ARROW_UP,
    WI_ARROW_STEADY,
    WI_ARROW_DOWN,
    WI_ARROW_DOWN_FAST,
    WI_COUNT
};

static const int kWeatherIconWidth = 16;

static const uint8_t kWeatherIcons[WI_COUNT][16] = {
    // WI_SUN — disc with horizontal arms, top/bottom stubs, diagonal ray dots
    { 0x18, 0x5A, 0x18, 0x00, 0x00, 0x18, 0x3C, 0xBD, 0xBD, 0x3C, 0x18, 0x00, 0x00, 0x18, 0x5A, 0x18 },
    // WI_MOON — crescent + two star dots
    { 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x99, 0x00, 0x00, 0x02, 0x00, 0x08, 0x00 },
    // WI_PARTLY — sun top-left, cloud bottom-right
    { 0x04, 0x0E, 0x1F, 0x0E, 0x04, 0x00, 0xE0, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0x40, 0x40, 0x00, 0x00 },
    // WI_CLOUD — two bumps, flat bottom
    { 0x30, 0x38, 0x3C, 0x3E, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3C, 0x38, 0x30 },
    // WI_DRIZZLE — cloud + three short vertical drops
    { 0x10, 0x18, 0x1C, 0x7E, 0x1F, 0x1F, 0x1F, 0x1F, 0x7F, 0x1F, 0x1F, 0x1F, 0x1E, 0x7C, 0x18, 0x10 },
    // WI_RAIN — cloud + three diagonal streaks
    { 0x10, 0x18, 0x3C, 0x5E, 0x9F, 0x1F, 0x1F, 0x3F, 0x5F, 0x9F, 0x1F, 0x1F, 0x3E, 0x5C, 0x98, 0x10 },
    // WI_SNOW — 6-arm flake (horizontal bar, vertical bar, 4 diagonal stubs)
    { 0x18, 0x18, 0x18, 0x18, 0x99, 0x5A, 0x3C, 0xFF, 0xFF, 0x3C, 0x5A, 0x99, 0x18, 0x18, 0x18, 0x18 },
    // WI_THUNDER — cloud + lightning slash
    { 0x10, 0x18, 0x1C, 0x1E, 0x9F, 0x9F, 0xDF, 0xDF, 0x7F, 0x7F, 0x3F, 0x3F, 0x1E, 0x1C, 0x18, 0x10 },
    // WI_FOG — three staggered horizontal lines
    { 0x08, 0x28, 0x2A, 0x2A, 0x2A, 0x2A, 0x2A, 0x2A, 0x2A, 0x2A, 0x2A, 0x2A, 0x2A, 0x2A, 0x28, 0x08 },
    // WI_ARROW_UP_FAST — two small up arrows
    { 0x00, 0x04, 0x06, 0x7F, 0x7F, 0x06, 0x04, 0x00, 0x00, 0x00, 0x04, 0x06, 0x7F, 0x7F, 0x06, 0x04 },
    // WI_ARROW_UP — single up arrow
    { 0x00, 0x00, 0x00, 0x00, 0x08, 0x0C, 0x0E, 0x7F, 0x7F, 0x0E, 0x0C, 0x08, 0x00, 0x00, 0x00, 0x00 },
    // WI_ARROW_STEADY — horizontal right arrow
    { 0x00, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x1C, 0x1C, 0x1C, 0x00, 0x00, 0x00 },
    // WI_ARROW_DOWN — single down arrow
    { 0x00, 0x00, 0x00, 0x00, 0x10, 0x30, 0x70, 0xFE, 0xFE, 0x70, 0x30, 0x10, 0x00, 0x00, 0x00, 0x00 },
    // WI_ARROW_DOWN_FAST — two small down arrows
    { 0x00, 0x10, 0x30, 0x7F, 0x7F, 0x30, 0x10, 0x00, 0x00, 0x00, 0x10, 0x30, 0x7F, 0x7F, 0x30, 0x10 },
};

// Map an OpenWeatherMap condition id (2xx..8xx) to an icon index.
// Anything unrecognised maps to a plain cloud.
inline int weatherIconIndex(int id, bool night = false)
{
    if (id >= 200 && id < 300) return WI_THUNDER;          // thunderstorm
    if (id >= 300 && id < 400) return WI_DRIZZLE;          // drizzle
    if (id >= 500 && id < 600)
        return (id == 511) ? WI_SNOW : WI_RAIN;            // 511 = freezing rain
    if (id >= 600 && id < 700) return WI_SNOW;             // snow
    if (id >= 700 && id < 800) return WI_FOG;              // mist, haze, dust, …
    if (id == 800) return night ? WI_MOON : WI_SUN;        // clear
    if (id == 801 || id == 802) return WI_PARTLY;          // few / scattered clouds
    if (id == 803 || id == 804) return WI_CLOUD;           // broken / overcast
    return WI_CLOUD;
}

#endif // WEATHER_ICONS_HPP
